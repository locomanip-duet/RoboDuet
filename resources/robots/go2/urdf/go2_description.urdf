Commit message: add sample test, remove go2 head_down

File: resources/robots/go2/urdf/go2_description.urdf (robot description, URDF)
Before this commit: robot go2_description, 29 links, 28 joints
Links:
- link Head_lower: geometry collision sphere radius=0.001
